# Keil uVision project gateway.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: GD32H759IM GigaDevice
  pack: GigaDevice.GD32H7xx_DFP.1.4.0
  cpu: IRAM(0x24000000,0x000D0000) IRAM2(0x00000000,0x00010000) IROM(0x08000000,0x0380000) XRAM(0x20000000,0x00020000) XRAM2(0x30000000,0x00004000) XRAM3(0x30004000,0x00004000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: gateway
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c misc: -Wno-padded -Wno-covered-switch-default
  c include: ..\Firmware\GD32H7xx_standard_peripheral\Include;..\Firmware\CMSIS\GD\GD32H7xx\Include;..\user\config;..\user\bsp;..\user\driver;..\user\interrupt;..\user\rtos;..\user\common;..\user\service\rs485;..\user\service\device;..\user\service\point;..\user\service\poll;..\user\protocol\modbus;..\user\protocol\can;..\user\task;..\user\app;..\vendor\FreeRTOS-Kernel-10.3.1\include;..\vendor\FreeRTOS-Kernel-10.3.1\portable\GCC\ARM_CM7\r0p1;..\user\net;..\vendor\lwip-2.1.2\src\include;..\vendor\lwip-2.1.2\port\GD32H7xx;..\vendor\lwip-2.1.2\port\GD32H7xx\FreeRTOS;..\user\gui;..\vendor\lvgl-9.2.2;..\vendor\lvgl-9.2.2\lvgl;..\user\service\gateway;..\user\service\config;..\user\service\automation;..\user\service\security;..\user\service\storage;..\user\service\time;..\user\service\watchdog;..\user\service\ops;..\user\service\diagnostics;..\user\service\ota
  asm include: ..\user\service\gateway
  memory RVCT4: ROM 0x8000000 size 0x380000
  memory RVCT6: RAM 0x20000000 size 0x20000
  memory RVCT7: RAM 0x30000000 size 0x4000
  memory RVCT8: RAM 0x30004000 size 0x4000
  memory RVCT9: RAM 0x24000000 size 0xd0000
  memory RVCT10: RAM 0x0 size 0x10000
  group Source Group 1
    ../user/: main.c
    ../Firmware/GD32H7xx_standard_peripheral/Source/: gd32h7xx_rcu.c gd32h7xx_gpio.c gd32h7xx_usart.c gd32h7xx_misc.c gd32h7xx_syscfg.c gd32h7xx_dma.c gd32h7xx_can.c gd32h7xx_i2c.c gd32h7xx_exmc.c gd32h7xx_tli.c gd32h7xx_ipa.c gd32h7xx_fmc.c gd32h7xx_fwdgt.c
  group bsp
    ../user/bsp/: bsp_cache.c bsp_debug_uart.c
  group FreeRTOS
    ../vendor/FreeRTOS-Kernel-10.3.1/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../user/app/: gateway_app.c rs485_smoke_test.c freertos_hooks.c
    ../user/driver/: drv_rs485.c drv_canfd.c
    ../user/interrupt/: gateway_irq.c
    ../user/task/: task_rs485.c task_can.c task_data.c
    ../user/service/rs485/: rs485_bus_manager.c
    ../user/service/device/: device_manager.c
    ../user/service/point/: point_db.c
    ../user/service/poll/: poll_scheduler.c
    ../user/protocol/modbus/: modbus_rtu_master.c
    ../user/protocol/can/: can_decoder.c
    ../user/common/: gw_message.c gw_time.c gw_crypto.c
    ../user/rtos/: rtos_objects.c
    ../vendor/FreeRTOS-Kernel-10.3.1/portable/GCC/ARM_CM7/r0p1/: port.c
    ../vendor/FreeRTOS-Kernel-10.3.1/portable/MemMang/: heap_4.c
    ../user/service/gateway/: gw_command_router.c gw_uplink.c
    ../user/service/storage/: gw_flash_store.c
    ../user/service/security/: gw_security.c
    ../user/service/config/: gw_config.c
    ../user/service/automation/: gw_alarm_rules.c
    ../user/service/time/: gw_sntp.c
    ../user/service/watchdog/: gw_watchdog.c
    ../user/service/ops/: gw_syslog.c gw_snmp.c
    ../user/service/diagnostics/: gw_diagnostics.c
    ../user/service/ota/: gw_ota.c
  group Ethernet
    ../user/net/: gw_eth_port.c gw_ethernetif.c gw_net_manager.c gw_tcp_server.c gw_lwip_port.c
    ../Firmware/GD32H7xx_standard_peripheral/Source/: gd32h7xx_enet.c
  group lwIP 2.1.2
    ../vendor/lwip-2.1.2/src/api/: api_lib.c api_msg.c err.c netbuf.c netifapi.c tcpip.c
    ../vendor/lwip-2.1.2/src/core/ipv4/: dhcp.c etharp.c icmp.c ip4.c ip4_addr.c ip4_frag.c
    ../vendor/lwip-2.1.2/src/core/: altcp.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../vendor/lwip-2.1.2/src/netif/: ethernet.c
    ../vendor/lwip-2.1.2/port/GD32H7xx/FreeRTOS/: sys_arch.c
    ../vendor/lwip-2.1.2/src/apps/sntp/: sntp.c
  group GUI
    ../user/gui/: gw_lcd.c gw_touch.c gw_lv_port.c gw_gui.c
    ../user/gui/sdram/: bsp_exmc_sdram.c
  group LVGL 9.2.2
    ../vendor/lvgl-9.2.2/lvgl/src/core/: lv_group.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_event.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c
    ../vendor/lvgl-9.2.2/lvgl/src/display/: lv_display.c
    ../vendor/lvgl-9.2.2/lvgl/src/draw/sw/blend/: lv_draw_sw_blend.c lv_draw_sw_blend_to_rgb565.c
    ../vendor/lvgl-9.2.2/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_border.c lv_draw_sw_box_shadow.c lv_draw_sw_fill.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_mask.c lv_draw_sw_mask_rect.c lv_draw_sw_transform.c lv_draw_sw_triangle.c
    ../vendor/lvgl-9.2.2/lvgl/src/draw/: lv_draw.c lv_draw_buf.c lv_draw_image.c lv_draw_label.c lv_draw_mask.c lv_draw_rect.c lv_image_decoder.c
    ../vendor/lvgl-9.2.2/lvgl/src/font/: lv_font.c lv_font_fmt_txt.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_20.c lv_font_montserrat_24.c
    ../vendor/lvgl-9.2.2/lvgl/src/indev/: lv_indev.c lv_indev_scroll.c
    ../vendor/lvgl-9.2.2/lvgl/src/layouts/: lv_layout.c
    ../vendor/lvgl-9.2.2/lvgl/src/libs/bin_decoder/: lv_bin_decoder.c
    ../vendor/lvgl-9.2.2/lvgl/src/misc/cache/: lv_cache.c lv_cache_entry.c lv_cache_lru_rb.c lv_image_cache.c lv_image_header_cache.c
    ../vendor/lvgl-9.2.2/lvgl/src/misc/: lv_anim.c lv_area.c lv_array.c lv_async.c lv_color.c lv_color_op.c lv_event.c lv_fs.c lv_ll.c lv_math.c lv_palette.c lv_rb.c lv_style.c lv_style_gen.c lv_text.c lv_timer.c lv_utils.c
    ../vendor/lvgl-9.2.2/lvgl/src/osal/: lv_os.c lv_os_none.c
    ../vendor/lvgl-9.2.2/lvgl/src/stdlib/builtin/: lv_mem_core_builtin.c lv_sprintf_builtin.c lv_string_builtin.c lv_tlsf.c
    ../vendor/lvgl-9.2.2/lvgl/src/stdlib/: lv_mem.c
    ../vendor/lvgl-9.2.2/lvgl/src/themes/: lv_theme.c
    ../vendor/lvgl-9.2.2/lvgl/src/tick/: lv_tick.c
    ../vendor/lvgl-9.2.2/lvgl/src/widgets/button/: lv_button.c
    ../vendor/lvgl-9.2.2/lvgl/src/widgets/buttonmatrix/: lv_buttonmatrix.c
    ../vendor/lvgl-9.2.2/lvgl/src/widgets/keyboard/: lv_keyboard.c
    ../vendor/lvgl-9.2.2/lvgl/src/widgets/label/: lv_label.c
    ../vendor/lvgl-9.2.2/lvgl/src/widgets/textarea/: lv_textarea.c
    ../vendor/lvgl-9.2.2/lvgl/src/: lv_init.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0
